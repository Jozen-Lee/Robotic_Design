# Keil uVision project Robotic_Design.uvprojx, settings and files
target Robotic_Design (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Robotic_Design +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --cpp11
  c include: ../Core/Inc;..\SRML;..\USP;..\USP\Application;..\USP\Drivers\Components;..\USP\Drivers\Devices\PS2;..\USP\Drivers\Devices\LCD;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\USP\Drivers\Devices\24CXX;..\USP\Drivers\Components\DELAY;..\USP\Drivers\Devices\BUS_STEERING;..\USP\Middlewares\UpperMonitor;..\USP\Drivers\Components\ROS_Connect
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/System
    ../USP/Application/: Service_Communication.cpp Service_Debug.cpp Service_Devices.cpp System_Config.cpp System_DataPool.cpp
    ../USP/: srml_config.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares/UpperMonitor
    ../USP/Middlewares/UpperMonitor/: UpperMonitor.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/Devices
    ../USP/Drivers/Devices/PS2/: ps2.cpp
    ../USP/Drivers/Devices/BUS_STEERING/: bus_steering.cpp
    ../USP/Drivers/Components/ROS_Connect/: ros_connect.c
  group Drivers/Components
    ../SRML/Drivers/Components/: drv_uart.c drv_timer.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
